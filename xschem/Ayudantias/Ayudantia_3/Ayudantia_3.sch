v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {title.sym} -4270 -70 0 0 {name=l1 author="Andrés Martínez"}
C {../Ayudantia_3/Sym_Inv.sym} -4080 -390 0 0 {name=X1}
C {../Ayudantia_3/Sym_NMOS.sym} -4080 -330 0 0 {name=X2}
